# Keil uVision project tinyos.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: tinyos
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./source/: switch.c main.c tBitmap.c tList.c tTask.c tTime.c tCpu.c app.c tEvent.c tSem.c tMbox.c tMemBlock.c tFlagGroup.c tMutex.c tTimer.c tHooks.h tHooks.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
